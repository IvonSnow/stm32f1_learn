# Keil uVision project demo.uvprojx, settings and files
target STM32F103RCT6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Lib\inc;.\Lib\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
  group HEADWARE
    ./Lib/src/: led.c
  group Lib
    ./Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
